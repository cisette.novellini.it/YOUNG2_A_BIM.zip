Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Shower-screens_Novellini_SIDE-YOUNG-A-95-corner-entry-2-hinged-do.ifc
Time: 2020-07-28T17:10:53
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcProxy, SIDE YOUNG A 95 corner entry - 2 hinged doors + 2 fixed panels
ePset_BIMobjectScript - Door Panel Material: Clear; Door Frame Material: Silver_B; LOD: 300; Door Width: 0.00095
ePset_BIMobject_BO - ProductName (BO_prodinfo): SIDE YOUNG A 95 corner entry - 2 hinged doors + 2 fixed panels; SKU (BO_prodsku): Y2A95L; ManufacturName (BO_Manufac): Novellini; BrandUrl (BO_brandurl): https://www.novellini.co.uk/; ProductFamily (BO_prodfam): YOUNG; ProductGroup (BO_prodgroup): YOUNG A; ManufacturCountry (BO_mancont): Italy; DesignCountry (BO_designcont): Italy; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 2000; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/novellini/product/Y2A95L; ProductDataUrl (BO_prodaturl): bimobject.com/novellini/product/Y2A95L; ProductUrl (BO_producturl): https://www.novellini.com/content/com/int/en/collections/shower-enclosures/young/young-a.html; InstallationInstructions (BO_montins): https://www.novellini.com/content/dam/novellini-archive/Pdf_Montaggio/box/young20/60092DY2%20Young2%20A/60092DY2_06%20Young2%20A.pdf; TechnicalDescription (BO_techcert): https://www.novellini.com/content/dam/novellini-archive/Pdf_Scheda/NOVELLINI/2019/int/YOUNGA-2019-INT.pdf; MaterialMain (BO_mainmat): Glass; MaterialSecondary (BO_secmat): Aluminium; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Shower screens; BimObjectCategoryCode (BO_bocat_code): sanitary-shower-screens; IfcClassification (BO_ifcclas): Object; UnspscCode (BO_unspsc): 30181507; Uniclass14Code (BO_uniclass_1_4_code): L72118; Uniclass14Description (BO_uniclass_1_4_desc): Bath screens, curtains; Uniclass20Code (BO_uniclass_2_0_code): PR-31-06; Uniclass20Description (BO_uniclass_2_0_desc): Bathing Fittings; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_76_07; Uniclass2015Description (BO_uniclass2015_desc): Bath panels; NBSReference (BO_nbs_ref): 31-06; NBSReferenceDescription (BO_nbs_desc): Bathing Fittings; OmniClassCode (BO_omniclass_code): 23-31 17 17; OmniClassDescription (BO_omniclass_name): Shower Enclosures; MasterFormat2014Code (BO_masterformat2014_code): 12 35 30.23; MasterFormat2014Description (BO_masterformat2014_name): Bathroom Casework; UniFormat2Code (BO_uniformat2_code): C1030; UniFormat2Description (BO_uniformat2_name): Fittings; RegionEurope (BO_europe): AT, BA, BE, BG, CH, CZ, DE, ES, FR, GB, GR, HR, HU, IT, LT, LU, ME, NL, NO, PL, RO, RU, SI, SK, UA
